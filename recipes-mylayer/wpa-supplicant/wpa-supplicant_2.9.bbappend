SUMMARY = "recipe to copy wpa_supplicant conf file to rootfs"
DESCRIPTION = "Recipe created by David Gherghita"
LICENSE = "CLOSED"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
