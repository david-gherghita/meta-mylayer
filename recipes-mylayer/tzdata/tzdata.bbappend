SUMMARY = "recipe to modify timezone"
DESCRIPTION = "Recipe created by David Gherghita"
LICENSE = "CLOSED"

DEFAULT_TIMEZONE = "Europe/Bucharest"
