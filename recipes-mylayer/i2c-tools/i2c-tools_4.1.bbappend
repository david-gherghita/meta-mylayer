SUMMARY = "recipe to update version of i2c-tools"
DESCRIPTION = "Recipe created by David Gherghita"
LICENSE = "CLOSED"

SRC_URI = "git://git.kernel.org/pub/scm/utils/i2c-tools/i2c-tools.git;protocol=https"
SRCREV = "0cadafa030496f913dc44ace38513dc57db15c4e"
S = "${WORKDIR}/git"

SRC_URI[md5sum] = "d9f772147ef3c43cd6cbe05a51554ef8"
SRC_URI[sha256sum] = "e0dde7383f2bc32be7e66ed7aa63b30c9eb93b43abaf98efe6075f1b7a8efc0d"
