SUMMARY = "recipe to copy ntp conf file to rootfs"
DESCRIPTION = "Recipe created by David Gherghita"
LICENSE = "CLOSED"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
